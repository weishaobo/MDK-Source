# Keil uVision project test.uvproj, settings and files
target TestProject (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: TestProject +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./source/: main.c calc_high_level.c dat2char.c position_in_array.c get_engage_time.c banfufeng.c
